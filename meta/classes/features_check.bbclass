distro_features_check.bbclass