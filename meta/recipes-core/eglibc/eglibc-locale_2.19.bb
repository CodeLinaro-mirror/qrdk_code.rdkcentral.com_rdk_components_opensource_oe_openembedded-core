require eglibc-locale.inc
INHIBIT_SYSROOT_STRIP = "1"
